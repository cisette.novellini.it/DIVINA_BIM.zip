Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Sanitary-Accessories_Novellini_Cental-tray-for-Divina-and-Divina-F-bath.ifc
Time: 2020-09-23T08:34:05
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, Cental tray for Divina and Divina F baths - 70 cm
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Cental tray for Divina and Divina F baths - 70 cm; SKU (BO_prodsku): R90VADIV70; ManufacturName (BO_Manufac): Novellini; BrandUrl (BO_brandurl): https://www.novellini.co.uk/; ProductFamily (BO_prodfam): DIVINA; ProductGroup (BO_prodgroup): DIVINA OPTIONAL; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 700; Height (BO_height): 30; Depth (BO_depth): 200; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/novellini/product/R90VADIV70; ProductDataUrl (BO_prodaturl): bimobject.com/novellini/product/R90VADIV70; ProductUrl (BO_producturl): https://www.novellini.com/content/com/int/en/collections/baths/divina.html; MaterialMain (BO_mainmat): Polymer; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Sanitary Accessories; BimObjectCategoryCode (BO_bocat_code): sanitary-accessories1; IfcClassification (BO_ifcclas): Object; UnspscCode (BO_unspsc): 30181501; Uniclass14Code (BO_uniclass_1_4_code): L7211; Uniclass14Description (BO_uniclass_1_4_desc): Baths; Uniclass20Code (BO_uniclass_2_0_code): PR-31-06; Uniclass20Description (BO_uniclass_2_0_desc): Bathing Fittings; Uniclass2015Code (BO_uniclass2015_code): Ac_35_80_07; Uniclass2015Description (BO_uniclass2015_desc): Bathing; NBSReference (BO_nbs_ref): 31-06; NBSReferenceDescription (BO_nbs_desc): Bathing Fittings; OmniClassCode (BO_omniclass_code): 23-31 15 17; OmniClassDescription (BO_omniclass_name): Bathtub Components; MasterFormat2014Code (BO_masterformat2014_code): 10 28 00; MasterFormat2014Description (BO_masterformat2014_name): Toilet, Bath, and Laundry Accessories; UniFormat2Code (BO_uniformat2_code): E; UniFormat2Description (BO_uniformat2_name): EQUIPMENT & FURNISHINGS; RegionEurope (BO_europe): AL, AT, BA, BE, BG, CH, CY, DE, ES, FR, GB, GR, HR, IT, LT, LU, ME, MK, MT, NL, NO, PL, RO, RS, RU, SE, SI, SK, UA; RegionSouthAmerica (BO_southamerica): BR; RegionMiddleEast (BO_middleeast): AE, SA; RegionAsia (BO_asia): HK; RegionAfrica (BO_africa): MA, SC
